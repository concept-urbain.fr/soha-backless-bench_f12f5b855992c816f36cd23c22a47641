Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Soha Banquette bois lames perpendiculaires.IFC
Time: 2020-07-01T09:40:08
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: SOHA-BANQ-MUL-004_Default (14)
In: Default Storey
Material: Douka

# IfcBeam: SOHA-BANQ-MUL-005_Default (3)
In: Default Storey
Material: Douka

# IfcBuildingElementProxy: SOHA-BANQ-DRP-003_Default (2)
In: Default Storey
Name
SOHA-BANQ-DRP-003_Default | PSet_Mass_Property - Mass Measure: 44.4732; Area Measure: 4.11518; Volume Measure: 0.0221659
SOHA-BANQ-DRP-003_Default

# IfcBuildingElementProxy: SOHA-BANQ-MUL-004_Default (13)
In: Default Storey
Material: Douka

# IfcBuildingElementProxy: SOHA-BANQ-MUL-005_Default (2)
In: Default Storey
Material: Douka

# IfcFooting: SOHA-BANQ-MUL-004_Default
In: Default Storey
Material: Douka
