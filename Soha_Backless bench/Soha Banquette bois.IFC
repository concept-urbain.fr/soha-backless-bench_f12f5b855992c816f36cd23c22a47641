Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Soha Banquette bois.IFC
Time: 2020-07-01T09:38:59
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: SOHA-BANQ-MUL-009_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 40.8881; Area Measure: 3.80196; Volume Measure: 0.0233854

# IfcBuildingElementProxy: SOHA-BANQ-MUL-007_Default (6)
In: Default Storey
Material: Moabi

# IfcBuildingElementProxy: SOHA-BANQ-MUL-010_Default (2)
In: Default Storey
Material: Moabi
